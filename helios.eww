<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\helios.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>Project</project>
                <configuration>STM324x7I_EVAL</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>STM324x9I_EVAL</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>STM324xG_EVAL</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
